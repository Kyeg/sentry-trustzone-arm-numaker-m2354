# Keil uVision project NonSecure.uvprojx, settings and files
target Nonsecure (6220000::V6.22::ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.26
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: Nonsecure +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=5
  c define: DEBUG_PORT=UART1_NS
  c misc: -fexceptions -fno-rtti
  c include: ..\..\;..\..\Nonsecure;..\..\Library_BSP\CMSIS\Include;..\..\Library_BSP\Device\Nuvoton\M2354\Include;..\..\Library_BSP\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: nonsecure.sct
  group CMSIS
    ../../Library_BSP/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../../Library_BSP/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.s
  group Library
    ../../Secure/lib/: nsclib_Secure.o
    ../../Library_BSP/StdDriver/src/: retarget.c gpio.c uart.c timer.c
  group User
    ../: main_ns.c
