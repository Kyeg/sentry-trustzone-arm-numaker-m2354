# Keil uVision project Secure.uvprojx, settings and files
target Secure (6220000::V6.22::ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.26
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: Secure
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c misc: -mfloat-abi=soft -Wno-documentation -Wno-reserved-id-macro -fexceptions -fno-rtti
  c include: ..\..\;..\..\Library_BSP\CMSIS\Include;..\..\Library_BSP\Device\Nuvoton\M2354\Include;..\..\Library_BSP\StdDriver\inc;..\..\Library_ThirdParty\Ureka;..\..\Library_ThirdParty\Ureka\logic;..\..\Library_ThirdParty\Ureka\logic\pipeline_flow;..\..\Library_ThirdParty\Ureka\logic\stage_worker;..\..\Library_ThirdParty\Ureka\model;..\..\Library_ThirdParty\Ureka\model\data_model;..\..\Library_ThirdParty\Ureka\model\message_model;..\..\Library_ThirdParty\Ureka\resource;..\..\Library_ThirdParty\Ureka\resource\communication;..\..\Library_ThirdParty\Ureka\resource\crypto;..\..\Library_ThirdParty\Ureka\resource\logger;..\..\Library_ThirdParty\Ureka\resource\storage
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\secure.sct
  link misc: --import-cmse-lib-out ..\lib\nsclib_Secure.o
  group CMSIS
    ../../Library_BSP/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../../Library_BSP/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.s
  group Library
    ../../Library_BSP/StdDriver/src/: retarget.c clk.c gpio.c crypto.c fmc.c rng.c sys.c keystore.c uart.c
  group User
    ../../: partition_M2354.h
    ../: main.cpp
    ./: my_crypto.c
    ../../Library_ThirdParty/Ureka/: jsonBuild.cpp
